Intruder Detector Portenta Fusion 360 editable (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Cap", "Box (1)"